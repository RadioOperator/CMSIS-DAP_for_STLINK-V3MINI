# Keil uVision project STLINKv3DAPv2_WinUSB+VCP.uvprojx, settings and files
target STLINKv3DAPv2_WinUSB+VCP (6120000::V6.12::.\ARMCLANG)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20010000,0x30000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STLINKv3DAPv2_WinUSB+VCP +hex
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: C:\Keil\ARM\PACK\ARM\CMSIS\5.6.0\CMSIS\Include;C:\Keil\ARM\PACK\ARM\CMSIS\5.6.0\CMSIS\Driver\Include;.\CMSIS-DAP;.\RTE\USB;.\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c STLINK_V3MINI_BSP.c USBD_User_CustomClass_0.c USBD_User_CDC_ACM_UART_0.c
  group CMSIS-DAP
    ./CMSIS-DAP/: DAP.c DAP.h DAP_config.h JTAG_DP.c SW_DP.c SWO.c
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, USB:CORE 6.13.6, USB:Device 6.13.6, USB:Device:CDC 6.13.6, USB:Device:Custom Class 6.13.6, CMSIS Driver:USART 1.13.0, CMSIS Driver:USB Device:High-speed 1.14.0, Device:STM32Cube Framework:Classic 1.2.7, Device:STM32Cube HAL:Common 1.2.7, Device:STM32Cube HAL:Cortex 1.2.7, Device:STM32Cube HAL:DMA 1.2.7, Device:STM32Cube HAL:GPIO 1.2.7, Device:STM32Cube HAL:PWR 1.2.7, Device:STM32Cube HAL:RCC 1.2.7, Device:STM32Cube HAL:USART 1.2.7, Device:Startup 1.2.4
